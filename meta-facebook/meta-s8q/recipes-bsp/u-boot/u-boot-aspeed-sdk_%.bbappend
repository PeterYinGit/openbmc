FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://s8q.cfg "
