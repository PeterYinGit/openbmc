FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://baliisland.cfg "
